# Keil uVision project Buzzer_music.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: Buzzer_music +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c delay.h Timer.h key.c key.h LED_LIGHT_LZH.c LED_LIGHT_LZH.h
    ../LIBRARY/Timer/: Timer.c
    ../LIBRARY/delay/: delay.c
